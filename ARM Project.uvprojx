# Keil uVision project ARM Project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APP\Led_Ctrl;.\COMMON;.\HAL\LED;.\MCAL\1. GPIO;.\MCAL\2. NVIC;.\MCAL\3. GPT
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/Led_Ctrl/: App_LedCtrl_Program.c
    ./APP/: main.c
  group HAL
    ./HAL/LED/: Led_Program.c
  group MCAL
    ./MCAL/1. GPIO/: Gpio_Program.c
    ./MCAL/2. NVIC/: Nvic_Program.c
    ./MCAL/3. GPT/: Gpt_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
